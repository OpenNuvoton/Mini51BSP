# Keil uVision project Timer_TriggerCountingMode.uvprojx, settings and files
target Timer_TriggerCountingMode (6150000::V6.15::ARMCLANG)
  device: Mini54LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Timer_TriggerCountingMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c timer.c
