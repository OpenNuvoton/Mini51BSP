# IAR project i2c_master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c_master.bin
  ILINK.IlinkOutputFile: i2c_master.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c
