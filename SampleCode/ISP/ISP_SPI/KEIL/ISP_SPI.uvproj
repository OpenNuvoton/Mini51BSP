# Keil uVision project ISP_SPI.uvproj, settings and files
target ISP_SPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Mini51LDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0xFFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: Mini51_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_Mini51
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
