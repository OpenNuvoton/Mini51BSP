# Keil uVision project I2C_FIFO_EEPROM.uvproj, settings and files
target I2C_FIFO_EEPROM (ARM-ADS)
  device: (Generic) Mini51 Series Nuvoton
  cpu: CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: I2C_FIFO_EEPROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Nu-LB-Mini51\inc
  library: MicroLIB
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c sys.c gpio.c
    ../../../../Library/Nu-LB-Mini51/src/: lcd_driver.c ascii_table.c
