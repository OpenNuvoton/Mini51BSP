# Keil uVision project Interrupt.uvprojx, settings and files
target Interrupt (6120000::V6.12::.\ARMCLANG)
  device: Mini54LDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Interrupt
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include;..\..\..\..\Library\Nu-LB-Mini51\inc;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/Nu-LB-Mini51/src/: Ascii_Table.c LCD_Driver.c
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
