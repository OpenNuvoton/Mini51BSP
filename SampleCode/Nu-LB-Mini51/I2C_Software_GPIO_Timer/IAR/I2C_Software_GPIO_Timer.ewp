# IAR project I2C_Software_GPIO_Timer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini51Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\Nu-LB-Mini51\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Software_GPIO_Timer.bin
  ILINK.IlinkOutputFile: I2C_Software_GPIO_Timer.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../../../../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
    ../../../../Library/Nu-LB-Mini51/src/: i2c_software_gpio_with_timer.c
  group User
    ../: main.c
